# Keil uVision project DAS02418 MultiFuncMotorPrgm N76E003 SVPWM BLDC ACIM.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: DAS02418 MultiFuncMotorPrgm N76E003 SVPWM BLDC ACIM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 3PhaseInverter.c BLDC with Hall.c BLDC_Sensorless.c main.c NTC.c SVPWM.c 3PhaseInverter.h BLDC with Hall.h BLDC_Sensorless.h N76E003.h NTC.h SVPWM.h
