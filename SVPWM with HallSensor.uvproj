# Keil uVision project SVPWM with HallSensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: SVPWM with HallSensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 SVPWM.c SVPWM.h 3PhaseInverter.c main.c BLDC with Hall.c 3PhaseInverter.h BLDC with Hall.h
